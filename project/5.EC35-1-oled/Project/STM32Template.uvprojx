# Keil uVision project STM32Template.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32Template +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: -Wno-invalid-source-encoding
  c include: ..\Firmware\STM32F10x_StdPeriph_Driver\inc;..\User;..\Hardware\usart;..\Firmware\CMSIS\CM3\CoreSupport;..\Hardware\EC11;..\Hardware\oled0.92
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c stm32f10x_conf.h systick.c systick.h
  group CMSIS
    ../Firmware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Firmware
    ../Firmware/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_spi.c
  group Hardware
    ../Hardware/usart/: usart.c usart.h
    ../Hardware/EC11/: EC35.c EC35.h
    ../Hardware/oled0.92/: oled.c oled.h bmp.h
software components: CMSIS:CORE 5.4.0
