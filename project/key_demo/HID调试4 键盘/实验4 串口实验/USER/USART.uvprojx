# Keil uVision project USART.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\USB\STM32_USB-FS-Device_Driver\src;..\USB\Config;..\USB\STM32_USB-FS-Device_Driver\inc\type;..\USB\STM32_USB-FS-Device_Driver\inc\lib;..\USB\STM32_USB-FS-Device_Driver\inc\regs;..\USB\STM32_USB-FS-Device_Driver\inc\def;..\USB\STM32_USB-FS-Device_Driver\inc\core;..\USB\STM32_USB-FS-Device_Driver\inc\init;..\USB\STM32_USB-FS-Device_Driver\inc\sil;..\USB\STM32_USB-FS-Device_Driver\inc\mem;..\USB\STM32_USB-FS-Device_Driver\inc\int;..\HARDWARE\MatrixKeys;..\HARDWARE\oled0.92;..\HARDWARE\EC11;..\HARDWARE\menu;..\HARDWARE\wq25xx;..\FATFS\source;..\HARDWARE\USER_FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/MatrixKeys/: MatrixKeys.c
    ../HARDWARE/HID/: HID_FONT.h
    ../HARDWARE/oled0.92/: oled.c oled.h bmp.h
    ../HARDWARE/EC11/: EC11.c
    ../HARDWARE/wq25xx/: w25qxx.c
    ../HARDWARE/USER_FATFS/: myfatfs.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group USB_CONFIG
    ../USB/Config/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FATFS
    ../FATFS/source/: diskio.c ff.c ffunicode.c malloc.c ffconf.h
