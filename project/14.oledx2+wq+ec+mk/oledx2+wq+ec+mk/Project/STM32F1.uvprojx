# Keil uVision project STM32F1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Firmware\CMSIS\CM3\CoreSupport;..\Firmware\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Firmware\STM32F10x_StdPeriph_Driver\inc;..\Middleware\usart;..\Middleware\spi;..\Hardware\OLED;..\Hardware\MatrixKeys;..\Hardware\Utilities;..\Hardware\EC35;..\Hardware\OLED_92;..\Hardware\OLED_42;..\Hardware\wq25xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c systick.c
  group CMSIS
    ../Firmware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Firmware
    ../Firmware/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/MatrixKeys/: MatrixKeys.c
    ../Hardware/Utilities/: Menu.c Utikites.c save_pic.c save_pic.h
    ../Hardware/wq25xx/: w25qxx.c
    ../Hardware/EC35/: EC35.c
    ../Hardware/OLED_92/: oled_92.c oled_92.h
  group Middleware
    ../Middleware/usart/: Usart0.c
    ../Middleware/spi/: Soft_SPI0.c SPI0.c
